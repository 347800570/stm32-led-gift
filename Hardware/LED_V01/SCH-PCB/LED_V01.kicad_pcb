# Repository 347800570/stm32-led-gift

File README.md:

# 基于STM32的灯带礼物制作项目

用木板、可寻址灯带和自己设计的控制板，制作一块能遥控、感知温度、跟随音乐闪动的灯牌。
采用 STM32F042G6U6TR + WS2812B，提供 KiCad 硬件、CubeMX/Keil 固件和基础实验。固件独立运行，不需要 Wi-Fi、手机应用或联网服务，也不是 WLED 固件移植版。

## 能做什么

| 遥控键 | 灯光效果 |
| --- | --- |
| 1 | 整条红橙黄绿蓝靛紫循环渐变 |
| 2 | 暖橙呼吸 |
| 3 | 沿灯珠编号流动的彩虹 |
| 4 | 蓝白流星 |
| 5 | 随机星光 |
| 6 | 根据实际位置，从木板底部向上燃烧的火焰 |
| 7 | 环境冷暖：18°C蓝、25°C绿、32°C红 |
| 8 | 根据声音大小，自下而上点亮的音量柱 |
| 9 | 检测鼓点能量突增，触发整条短暂闪光 |

POWER开关；+/-调整亮度；LEFT/RIGHT在1～7号调速度，在8/9号调声音灵敏度。
关灯时其他键不唤醒，也不修改设置。上电默认3号、15%亮度、速度和灵敏度均为第3档；调整只保存在RAM，断电恢复默认。

## 选择版本

| 固件 | 灯珠数 | 说明 |
| --- | --- | --- |
| [MPLT-67.hex](firmware/MPLT-67.hex) | 67 | 原始布局，27×8空间网格 |
| [SRKL-74.hex](firmware/SRKL-74.hex) | 74 | 新布局，33×12空间网格 |

74颗版本的9种模式已由作者上板验证正常。两套固件均在Windows上用ARMCC5重新编译并进行ARM指令仿真回归；仿真不验证实际电气时序。
首次发行 v0.1.0 为原型参考版本。硬件DRC仍有29项违规，不能把本仓库当作已完成生产审查的设计。

## 快速开始

1. 准备对应控制板、5V WS2812B灯带、NEC红外遥控器、5V电源及USB数据线或SWD下载器。
2. 将灯带DIN接到PB0对应的LED1_DATA，灯带和控制板共地，核对5V极性。
3. 用STM32CubeProgrammer下载对应HEX。SWD连接SWDIO、SWCLK、GND，必要时加NRST；USB DFU操作见[接线与烧录](docs/quick-start.md)。
4. 正常启动时BOOT0为低，复位后应出现彩虹。串口115200、8N1能看到READY日志。
5. 按遥控器1～9逐项验证。空间灯效要求实物排布匹配坐标文件；其他布局须重新编译。

电源按5V设计。Type-C接口并不意味着可以直接使用充电器标称的全部功率；供电能力取决于5V档、线缆、接口及布线。软件最高30%亮度不是闭环电流限制。

## 从哪里开始看

- [接线、下载和遥控使用](docs/quick-start.md)
- [编译、测试与移植布局](docs/development.md)
- [硬件状态与已知问题](docs/hardware.md)
- [基础实验导航](Software/Test/README.md)
- [67颗工程说明](Software/Official%20Version/MPLT_V03/README.md)
- [74颗工程说明](Software/Official%20Version/SRKL_V01/README.md)
- [原理图PDF](Hardware/LED_V01/Schematic.pdf)、[BOM](Hardware/LED_V01/BOM.csv)、[KiCad工程](Hardware/LED_V01/SCH-PCB/LED_V01.kicad_pro)
- [版本记录](CHANGELOG.md)、[贡献说明](CONTRIBUTING.md)、[第三方许可](THIRD_PARTY_NOTICES.md)

## 已知限制

- 使用同一套硬件引脚和指定NEC键码；其他遥控器需要重新学习键码。
- 声控是低频能量突增检测，不是音乐语义识别；拍桌也可能触发，部分音乐会漏检。
- 74颗版RAM静态分配5976/6144 B（含1024 B预留栈），继续增加灯珠或功能前必须重新核算。
- 温度仅用于显示环境冷暖，不承担过温保护。
- PCB为原型资料，DRC未通过；未发布可直接下单的Gerber附件。

## 许可

自有应用代码、测试和文档采用[MIT](LICENSE)；自有硬件设计采用[CERN-OHL-P-2.0](LICENSES/CERN-OHL-P-2.0.txt)。
STM32、CMSIS以及第三方元件库保留各自许可，以上授权不替代第三方许可，范围见[声明](THIRD_PARTY_NOTICES.md)。

## KiCad design Hardware/LED_V01/SCH-PCB/LED_V01.kicad_pcb

Parts:
C1, C3, C5, C7, C9, C10, C13, C17, C19, C21: 100nF; C0603
C2, C4: 2.2uF; C0805
C6: 10uF; C0805
C8, C15: 10nF; C0603
C11, C12, C16: 1uF; C0603
C14: 4.7uF; C0805
C18: 100uF 10V; CAP-TH_BD5.0-P2.00-D0.5-FD; MPN ERA10V100M5X7; LCSC Part C49256785
CN1: ZX-SH1.0-7PWT; CONN-SMD_7P-P1.00_MEGASTAR_ZX-SH1.0-7PWT; MPN ZX-SH1.0-7PWT; LCSC Part C7430449
D1: SMF6.0A; SOD-123FL_L2.8-W1.9-LS3.7-RD; MPN SMF6.0A; LCSC Part C2857264
D2: USBLC6-2SC6; SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL; MPN USBLC6-2SC6; LCSC Part C2827654
D3, D4: PESD5V0S1BA; SOD-323_L1.7-W1.3-LS2.5-BI; MPN PESD5V0S1BA; LCSC Part C5158048
F1: Fuse; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder; LCSC Part C135343
H1: P= 2.54; HDR-TH_3P-P2.54-V-M_PZ254V-11-03P; MPN PZ254V-11-03P; LCSC Part C2937625
MIC1: ZTS6216; MIC-SMD_4P-L2.8-W1.9-P1.84-TL; MPN ZTS6216; LCSC Part C481302
R1, R3, R5, R7, R11, R17, R19: 10K; R0603
R2, R18: 1K; R0603
R4, R10: 47R; R0603
R8: 2K; R0603
R9, R12: 47K; R0603
R13, R14: 5.1K; R0603
SW1, SW2: TS-1088-AR02016; SW-SMD_L3.9-W3.0-P4.45; MPN TS-1088-AR02016; LCSC Part C720477
TP1, TP2: TP= 1.2mm
U1: DS18B20; TO-92-3_L4.9-W3.7-P1.27-L; MPN DS18B20(UMW); LCSC Part C376006
U2: DYWH-IRM-3638T; OPTO-TH_3P-L6.0-W5.6-P2.54_TSOP14656; MPN DYWH-IRM-3638T; LCSC Part C52125019
U3: TLV9001IDBVR; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR; MPN TLV9001IDBVR; LCSC Part C398363
U4, U6: VH3.96-3P ZZ; CONN-TH_3P-P3.96_FWF39601-S03S22W1B; MPN VH3.96-3P ZZ; LCSC Part C5379869
U5: SN74LVC2T45DCUR; VSSOP-8_L2.4-W2.1-P0.50-LS3.2-BR; MPN SN74LVC2T45DCUR; LCSC Part C15741
U7: TLV75533PDBVR; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR; MPN TLV75533PDBVR; LCSC Part C404027
U8: STM32F042G6U6TR; UFQFPN-28_L4.0-W4.0-P0.50-BL; MPN STM32F042G6U6TR; LCSC Part C2971720
USB1: TYPE-C 16PIN 2MD; USB-C-SMD_TYPE-C-16PIN-2MD-073; MPN TYPE-C 16PIN 2MD(073); LCSC Part C2765186

Connections:
+3.3V: C3.1, C7.1, C9.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, CN1.1, H1.1, MIC1.4 (VDD), R1.2, R3.2, R4.2, R5.2, R7.2, R17.2, U1.3 (VDD), U3.5 (V+), U5.8 (VCCB), U7.5 (OUT), U8.5 (VDDA), U8.17 (VDD), U8.18 (VDDIO2)
+5V: C10.1, C11.1, C18.1, C21.1, D1.1 (C), F1.2, U4.3, U5.1 (VCCA), U6.3, U7.1 (IN), U7.3 (EN)
/BOOT0: H1.2, R19.2, U8.1 (PB8-BOOT0)
/SWCLK: CN1.3, U8.22 (PA14)
/SWDIO: CN1.2, U8.21 (PA13)
/USART1_RX: CN1.5, U8.28 (PB7)
/USART1_TX: CN1.4, U8.27 (PB6)
/USB_D+: D2.3 (IO2), USB1.A6 (D+), USB1.B6 (D+)
/USB_D-: D2.1 (IO1), USB1.A7 (D-), USB1.B7 (D-)
/USB_DN: D2.6 (IO1), TP2.1, U8.19 (PA9[PA11])
/USB_DP: D2.4 (IO2), TP1.1, U8.20 (PA10[PA12])
/V_ref: C5.1, C6.1, R7.1, R8.2, R11.2, R12.2
ADC_MIC: C8.1, R10.1, U8.6 (PA0)
BUTTON: C1.1, R1.1, R2.2, U8.7 (PA1)
DS18B20: R3.1, U1.2 (DQ), U8.8 (PA2)
GND: C1.2, C2.2, C3.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C21.2, CN1.7, CN1.8, CN1.9, D1.2 (A), D2.2 (GND), D3.2, D4.2, H1.3, MIC1.2 (GND), MIC1.3 (GND), R11.1, R13.1, R14.1, R19.1, SW1.2, SW2.2, U1.1 (GND), U2.2 (GND), U3.2 (V-), U4.1, U5.4 (GND), U5.5 (DIR), U6.1, U7.2 (GND), U7.4 (NC), U8.16 (VSS), USB1.13 (SHIELD), USB1.14 (SHIELD), USB1.A1B12 (GND), USB1.B1A12 (GND)
IR: R5.1, U2.1 (OUT), U8.9 (PA3)
LED1_DATA: U5.7 (B1), U8.14 (PB0)
LED1_DATA_5V: U5.2 (A1), U6.2
LED2_DATA: U5.6 (B2), U8.15 (PB1)
LED2_DATA_5V: U4.2, U5.3 (A2)
MIC: C4.1, MIC1.1 (OUT)
NRST: C19.1, CN1.6, R17.1, R18.2, U8.4 (NRST)
unnamed: R2.1, SW1.1
unnamed: R18.1, SW2.1
unnamed: C2.1, R4.1, U2.3 (VCC)
unnamed: C4.2, R12.1, U3.3 (IN+)
unnamed: R8.1, R9.2, U3.4 (IN-)
unnamed: R9.1, R10.2, U3.1 (OUT)
unnamed: D3.1, R13.2, USB1.A5 (CC1)
unnamed: D4.1, R14.2, USB1.B5 (CC2)
VBUS: D2.5 (VBUS), F1.1, USB1.A4B9 (VBUS), USB1.B4A9 (VBUS)

Notes on the sheet:
VDDA
VDDIO2
麦克风
加一个拨码式开关，每次开关都要手动拔插有点累
控制器
放置时还需考虑 母头端子的碰撞体积
电源模块
温度传感器
R18得去掉，会影响复位和烧录
2026/8/6
这里改为510Ω
按钮、传感器
送给老欧和木木的开业礼物，祝他们的游戏大卖
这种按钮还是太小了不好按
VDD
红外接收

Board: 2 copper layers, 37.0 x 45.0 mm, 57 parts (0 on the bottom side), 32 nets.

File Hardware/LED_V01/BOM.csv:

"Refs","Value","Footprint","Qty","DNP"
"C1,C3,C5,C7,C9,C10,C13,C17,C19,C21","100nF","Aboka_Passive:C0603","10",""
"C2,C4","2.2uF","Aboka_Passive:C0805","2",""
"C6","10uF","Aboka_Passive:C0805","1",""
"C8,C15","10nF","Aboka_Passive:C0603","2",""
"C11,C12,C16","1uF","Aboka_Passive:C0603","3",""
"C14","4.7uF","Aboka_Passive:C0805","1",""
"C18","100uF 10V","Aboka_Passive:CAP-TH_BD5.0-P2.00-D0.5-FD","1",""
"CN1","ZX-SH1.0-7PWT","Aboka_Connector:CONN-SMD_7P-P1.00_MEGASTAR_ZX-SH1.0-7PWT","1",""
"D1","SMF6.0A","Aboka_Passive:SOD-123FL_L2.8-W1.9-LS3.7-RD","1",""
"D2","USBLC6-2SC6","Aboka_Discrete:SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BL","1",""
"D3,D4","PESD5V0S1BA","Aboka_Discrete:SOD-323_L1.7-W1.3-LS2.5-BI","2",""
"F1","Fuse","Fuse:Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder","1",""
"H1","P= 2.54","Locator_Connector:HDR-TH_3P-P2.54-V-M_PZ254V-11-03P","1",""
"MIC1","ZTS6216","Aboka_IC:MIC-SMD_4P-L2.8-W1.9-P1.84-TL","1",""
"R1,R3,R5,R7,R11,R17,R19","10K","Aboka_Passive:R0603","7",""
"R2,R18","1K","Aboka_Passive:R0603","2",""
"R4,R10","47R","Aboka_Passive:R0603","2",""
"R8","2K","Aboka_Passive:R0603","1",""
"R9,R12","47K","Aboka_Passive:R0603","2",""
"R13,R14","5.1K","Aboka_Passive:R0603","2",""
"SW1,SW2","TS-1088-AR02016","Aboka_Electromechanical:SW-SMD_L3.9-W3.0-P4.45","2",""
"TP1,TP2","~","Aboka_Board:TP= 1.2mm","2",""
"U1","DS18B20","Aboka_IC:TO-92-3_L4.9-W3.7-P1.27-L","1",""
"U2","DYWH-IRM-3638T","Aboka_IC:OPTO-TH_3P-L6.0-W5.6-P2.54_TSOP14656","1",""
"U3","TLV9001IDBVR","Aboka_IC:SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR","1",""
"U4,U6","VH3.96-3P ZZ","Aboka_Connector:CONN-TH_3P-P3.96_FWF39601-S03S22W1B","2",""
"U5","SN74LVC2T45DCUR","Aboka_IC:VSSOP-8_L2.4-W2.1-P0.50-LS3.2-BR","1",""
"U7","TLV75533PDBVR","Aboka_IC:SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR","1",""
"U8","STM32F042G6U6TR","Aboka_IC:UFQFPN-28_L4.0-W4.0-P0.50-BL","1",""
"USB1","TYPE-C 16PIN 2MD","Aboka_Connector:USB-C-SMD_TYPE-C-16PIN-2MD-073","1",""

## Code that names these connections

File Software/Test/9_Light Led 2/Light Led 2.ioc (part):

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Mcu.Name=STM32F042G(4-6)Ux
Mcu.Package=UFQFPN28
Mcu.UserName=STM32F042G6Ux
PA0.Mode=IN0
PA0.Signal=ADC_IN0
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=Key
PA1.Signal=GPIO_Input
PA11.Mode=Device
PA11.Signal=USB_DM
PA12.Mode=Device
PA12.Signal=USB_DP
PA13.Mode=Serial_Wire
PA13.Signal=SYS_SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_SWCLK
PA2.GPIOParameters=PinState,GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultOutputPP
PA2.GPIO_Label=DS18B20_DQ
PA2.GPIO_ModeDefaultOutputPP=GPIO_MODE_OUTPUT_OD
PA2.GPIO_PuPd=GPIO_NOPULL
PA2.PinState=GPIO_PIN_SET
PA2.Signal=GPIO_Output
PA3.GPIOParameters=GPIO_ModeDefaultEXTI
PA3.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_RISING_FALLING
PA3.Signal=GPXTI3
PB0.Signal=S_TIM3_CH3
PB1.Signal=S_TIM3_CH4
PB6.Mode=Asynchronous
PB6.Signal=USART1_TX
PB7.Mode=Asynchronous
PB7.Signal=USART1_RX
RCC.SYSCLKFreq_VALUE=48000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_HSI48
board=custom

File Software/Test/3_Light Led/Core/Src/main.c:

/* USER CODE BEGIN Header */
/**
  ******************************************************************************
  * @file           : main.c
  * @brief          : Main program body
  ******************************************************************************
  * @attention
  *
  * Copyright (c) 2026 STMicroelectronics.
  * All rights reserved.
  *
  * This software is licensed under terms that can be found in the LICENSE file
  * in the root directory of this software component.
  * If no LICENSE file comes with this software, it is provided AS-IS.
  *
  ******************************************************************************
  */
/* USER CODE END Header */
/* Includes ------------------------------------------------------------------*/
#include "main.h"
#include "dma.h"
#include "tim.h"
#include "usart.h"
#include "usb.h"
#include "gpio.h"

/* Private includes ----------------------------------------------------------*/
/* USER CODE BEGIN Includes */

/* USER CODE END Includes */

/* Private typedef -----------------------------------------------------------*/
/* USER CODE BEGIN PTD */

/* USER CODE END PTD */

/* Private define ------------------------------------------------------------*/
/* USER CODE BEGIN PD */
#define WS2812_LED_COUNT          10U
#define WS2812_BITS_PER_LED       24U
#define WS2812_RESET_SLOTS        64U
#define WS2812_BUFFER_SIZE        ((WS2812_LED_COUNT * WS2812_BITS_PER_LED) + WS2812_RESET_SLOTS)

/* TIM3 runs at 48 MHz with ARR=59: 19 ticks encode 0, 38 ticks encode 1. */
#define WS2812_DUTY_0             19U
#define WS2812_DUTY_1             38U
#define WS2812_DMA_TIMEOUT_MS     100U
#define WS2812_TEST_BRIGHTNESS    16U
/* USER CODE END PD */

/* Private macro -------------------------------------------------------------*/
/* USER CODE BEGIN PM */

/* USER CODE END PM */

/* Private variables ---------------------------------------------------------*/

/* USER CODE BEGIN PV */
static uint16_t ws2812_pwm_buffer[WS2812_BUFFER_SIZE];
static volatile uint8_t ws2812_dma_complete;
/* USER CODE END PV */

/* Private function prototypes -----------------------------------------------*/
void SystemClock_Config(void);
/* USER CODE BEGIN PFP */
static void WS2812_FillSolidColor(uint8_t red, uint8_t green, uint8_t blue);
static HAL_StatusTypeDef WS2812_Send(uint32_t channel);
/* USER CODE END PFP */

/* Private user code ---------------------------------------------------------*/
/* USER CODE BEGIN 0 */

/**
  * @brief Convert one solid RGB color into a WS2812B PWM duty-cycle stream.
  * @note  WS2812B expects each pixel in GRB order, most-significant bit first.
  */
static void WS2812_FillSolidColor(uint8_t red, uint8_t green, uint8_t blue)
{
  uint32_t color = ((uint32_t)green << 16U) |
                   ((uint32_t)red << 8U) |
                   (uint32_t)blue;
  uint32_t index = 0U;

  for (uint32_t led = 0U; led < WS2812_LED_COUNT; led++)
  {
    for (uint32_t bit = 0U; bit < WS2812_BITS_PER_LED; bit++)
    {
      uint32_t mask = 1UL << (23U - bit);
      ws2812_pwm_buffer[index++] = ((color & mask) != 0U) ?
                                    WS2812_DUTY_1 : WS2812_DUTY_0;
    }
  }

  /* A low level longer than 50 us makes the LEDs latch the received color. */
  while (index < WS2812_BUFFER_SIZE)
  {
    ws2812_pwm_buffer[index++] = 0U;
  }
}

/**
  * @brief Send the prepared PWM stream through one TIM3 channel.
  */
static HAL_StatusTypeDef WS2812_Send(uint32_t channel)
{
  HAL_StatusTypeDef status;
  uint32_t start_tick;

  ws2812_dma_complete = 0U;
  __HAL_TIM_SET_COMPARE(&htim3, channel, 0U);
  __HAL_TIM_SET_COUNTER(&htim3, 0U);

  status = HAL_TIM_PWM_Start_DMA(&htim3,
                                 channel,
                                 (const uint32_t *)ws2812_pwm_buffer,
                                 (uint16_t)WS2812_BUFFER_SIZE);
  if (status != HAL_OK)
  {
    return status;
  }

  start_tick = HAL_GetTick();
  while (ws2812_dma_complete == 0U)
  {
    if ((HAL_GetTick() - start_tick) >= WS2812_DMA_TIMEOUT_MS)
    {
      (void)HAL_TIM_PWM_Stop_DMA(&htim3, channel);
      __HAL_TIM_SET_COMPARE(&htim3, channel, 0U);
      return HAL_TIMEOUT;
    }
  }

  (void)HAL_TIM_PWM_Stop_DMA(&htim3, channel);
  __HAL_TIM_SET_COMPARE(&htim3, channel, 0U);
  return HAL_OK;
}

/* USER CODE END 0 */

/**
  * @brief  The application entry point.
  * @retval int
  */
int main(void)
{

  /* USER CODE BEGIN 1 */

  /* USER CODE END 1 */

  /* MCU Configuration--------------------------------------------------------*/

  /* Reset of all peripherals, Initializes the Flash interface and the Systick. */
  HAL_Init();

  /* USER CODE BEGIN Init */

  /* USER CODE END Init */

  /* Configure the system clock */
  SystemClock_Config();

  /* USER CODE BEGIN SysInit */

  /* USER CODE END SysInit */

  /* Initialize all configured peripherals */
  MX_GPIO_Init();
  MX_DMA_Init();
  MX_TIM1_Init();
  MX_USART1_UART_Init();
  MX_USB_PCD_Init();
  MX_TIM3_Init();
  /* USER CODE BEGIN 2 */

  /* Allow the 5 V LED supply and the level shifter to become stable. */
  HAL_Delay(100U);

  /* LED1_DATA on PB0/TIM3_CH3: ten low-brightness red pixels. */
  WS2812_FillSolidColor(WS2812_TEST_BRIGHTNESS, 0U, 0U);
  if (WS2812_Send(TIM_CHANNEL_3) != HAL_OK)
  {
    Error_Handler();
  }

  /* LED2_DATA on PB1/TIM3_CH4: ten low-brightness green pixels. */
  WS2812_FillSolidColor(0U, WS2812_TEST_BRIGHTNESS, 0U);
  if (WS2812_Send(TIM_CHANNEL_4) != HAL_OK)
  {
    Error_Handler();
  }

  /* USER CODE END 2 */

  /* Infinite loop */
  /* USER CODE BEGIN WHILE */
  while (1)
  {
    /* USER CODE END WHILE */

    /* USER CODE BEGIN 3 */
  }
  /* USER CODE END 3 */
}

/**
  * @brief System Clock Configuration
  * @retval None
  */
void SystemClock_Config(void)
{
  RCC_OscInitTypeDef RCC_OscInitStruct = {0};
  RCC_ClkInitTypeDef RCC_ClkInitStruct = {0};
  RCC_PeriphCLKInitTypeDef PeriphClkInit = {0};

  /** Initializes the RCC Oscillators according to the specified parameters
  * in the RCC_OscInitTypeDef structure.
  */
  RCC_OscInitStruct.OscillatorType = RCC_OSCILLATORTYPE_HSI48;
  RCC_OscInitStruct.HSI48State = RCC_HSI48_ON;
  RCC_OscInitStruct.PLL.PLLState = RCC_PLL_NONE;
  if (HAL_RCC_OscConfig(&RCC_OscInitStruct) != HAL_OK)
  {
    Error_Handler();
  }

  /** Initializes the CPU, AHB and APB buses clocks
  */
  RCC_ClkInitStruct.ClockType = RCC_CLOCKTYPE_HCLK|RCC_CLOCKTYPE_SYSCLK
                              |RCC_CLOCKTYPE_PCLK1;
  RCC_ClkInitStruct.SYSCLKSource = RCC_SYSCLKSOURCE_HSI48;
  RCC_ClkInitStruct.AHBCLKDivider = RCC_SYSCLK_DIV1;
  RCC_ClkInitStruct.APB1CLKDivider = RCC_HCLK_DIV1;

  if (HAL_RCC_ClockConfig(&RCC_ClkInitStruct, FLASH_LATENCY_1) != HAL_OK)
  {
    Error_Handler();
  }
  PeriphClkInit.PeriphClockSelection = RCC_PERIPHCLK_USB|RCC_PERIPHCLK_USART1;
  PeriphClkInit.Usart1ClockSelection = RCC_USART1CLKSOURCE_PCLK1;
  PeriphClkInit.UsbClockSelection = RCC_USBCLKSOURCE_HSI48;

  if (HAL_RCCEx_PeriphCLKConfig(&PeriphClkInit) != HAL_OK)
  {
    Error_Handler();
  }
}

/* USER CODE BEGIN 4 */

/**
  * @brief Called by the HAL after one TIM PWM DMA transfer finishes.
  */
void HAL_TIM_PWM_PulseFinishedCallback(TIM_HandleTypeDef *htim)
{
  if (htim->Instance == TIM3)
  {
    ws2812_dma_complete = 1U;
  }
}

/* USER CODE END 4 */

/**
  * @brief  This function is executed in case of error occurrence.
  * @retval None
  */
void Error_Handler(void)
{
  /* USER CODE BEGIN Error_Handler_Debug */
  /* User can add his own implementation to report the HAL error return state */
  __disable_irq();
  while (1)
  {
  }
  /* USER CODE END Error_Handler_Debug */
}
#ifdef USE_FULL_ASSERT
/**
  * @brief  Reports the name of the source file and the source line number
  *         where the assert_param error has occurred.
  * @param  file: pointer to the source file name
  * @param  line: assert_param error line source number
  * @retval None
  */
void assert_failed(uint8_t *file, uint32_t line)
{
  /* USER CODE BEGIN 6 */
  /* User can add his own implementation to report the file name and line number,
     ex: printf("Wrong parameters value: file %s on line %d\r\n", file, line) */
  /* USER CODE END 6 */
}
#endif /* USE_FULL_ASSERT */
